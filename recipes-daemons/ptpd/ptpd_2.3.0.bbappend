FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

SRC_URI += "file://ptpd-2.3.0-dpaa-etsec.patch"


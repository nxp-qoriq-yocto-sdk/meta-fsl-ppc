PR_append_fsl = "+${DISTRO}.0"

FILESEXTRAPATHS_prepend_fsl := "${THISDIR}/files:"

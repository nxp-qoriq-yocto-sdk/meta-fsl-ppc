EXTRA_OECONF_append_fsl = " --with-fexceptions"

PR_append_fsl = "+${DISTRO}.0"

require recipes-kernel/linux/linux-qoriq.inc

SRC_URI = "git://git.freescale.com/ppc/sdk/linux.git;nobranch=1 \
"
SRCREV = "6619b8b55796cdf0cec04b66a71288edd3057229"

